# Keil uVision project cpputest_library.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L072CBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: cpputest_library (library)
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F072XX, CPPUTEST_STD_CPP_LIB_DISABLED
  c misc: --diag_suppress 1300 --diag_suppress 1293 --exceptions
  c include: .\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --vfemode=off
  group Source Group 1
    ./src/CppUTest/: CommandLineArguments.cpp CommandLineTestRunner.cpp JUnitTestOutput.cpp MemoryLeakDetector.cpp MemoryLeakWarningPlugin.cpp SimpleMutex.cpp SimpleString.cpp TeamCityTestOutput.cpp TestFailure.cpp TestFilter.cpp TestHarness_c.cpp TestMemoryAllocator.cpp TestOutput.cpp TestPlugin.cpp TestRegistry.cpp TestResult.cpp TestTestingFixture.cpp Utest.cpp
    ./src/Platforms/Keil/: UtestPlatform.cpp
